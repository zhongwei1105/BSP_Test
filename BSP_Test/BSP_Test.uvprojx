# Keil uVision project BSP_Test.uvprojx, settings and files
target M100 (6100000::V6.10.1::.\ARMCompiler6_10_1)
  device: M100 Generic
  pack: ThinkTech.Mizar_DFP.2.0.18
  cpu: IRAM(0x20000000,0x028000) IROM(0x10000000,0x100000) CPUTYPE("SC300") CLOCK(12000000) ELITTLE
  output: BSP_Test
  AfterMake: C:\Keil_v5\ARM\ARMCompiler6_10_1\bin\fromelf.exe --bin -o .\Objects\BSP_Test.bin .\Objects\BSP_Test.axf
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\ThinkTech_BSP\ThinkTech_LED;.\ThinkTech_BSP\ThinkTech_Timer;.\ThinkTech_BSP\ThinkTech_KEY;.\ThinkTech_BSP\ThinkTech_ESP8266;.\ThinkTech_BSP\ThinkTech_MCP2515;.\ThinkTech_BSP\ThinkTech_CMD;.\ThinkTech_BSP\ThinkTech_OBD
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group BSP_Test
    ./: BSP_Test.c
  group BSP
    ./ThinkTech_BSP/ThinkTech_LED/: ThinkTech_led.c
    ./ThinkTech_BSP/ThinkTech_Timer/: ThinkTech_Timer.c
    ./ThinkTech_BSP/ThinkTech_KEY/: ThinkTech_key.c
    ./ThinkTech_BSP/ThinkTech_ESP8266/: ThinkTech_ESP8266.c
    ./ThinkTech_BSP/ThinkTech_MCP2515/: ThinkTech_MCP2515.c
    ./ThinkTech_BSP/ThinkTech_CMD/: ThinkTech_cmd.c
    ./ThinkTech_BSP/ThinkTech_OBD/: ThinkTech_OBD.c Formula.c
software components: CMSIS:CORE 5.0.1, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:GPDMA 1.0.0, CMSIS Driver:GPIO 1.0.0, CMSIS Driver:MISC 1.0.0, CMSIS Driver:SPI:SSP(PL022) 1.0.0, CMSIS Driver:USART:UART(PL011) 1.0.0, Device:Startup 1.0.0
